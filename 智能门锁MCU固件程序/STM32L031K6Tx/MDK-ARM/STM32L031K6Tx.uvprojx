# Keil uVision project STM32L031K6Tx.uvprojx, settings and files
target STM32L031K6Tx (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L031K6Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: STM32L031K6Tx +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L031xx
  c include: ../Inc;            ../Drivers/STM32L0xx_HAL_Driver/Inc;            ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;            ../Drivers/CMSIS/Device/ST/STM32L0xx/Include;            ../Drivers/CMSIS/Include;            ..\Drivers\MCU_EEPROM;            ..\Drivers\Wireless;            ..\LockApp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32l031xx.s
  group Application/User
    ../Src/: appTask.c delay.c device.c uart.c user_call_back.c main.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Application/Frame
    ../Src/: crc16.c protocol.c
  group Application/Encrypt
    ../Src/: rsa.c encrypt.c aes.c 74.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c
  group Drivers/CMSIS
    ..//Src/: system_stm32l0xx.c
  group Drivers/MCU_EEPROM
    ../Drivers/MCU_EEPROM/: mcu_eeprom.c
  group Drivers/Wireless
    ../Drivers/Wireless/: spi.c wireless_app.c wireless_drv.c
target Sensor (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L031K6Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: as above
  output: STM32L031K6Tx +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L031xx
  c include: ../Inc;               ../Drivers/STM32L0xx_HAL_Driver/Inc;               ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;               ../Drivers/CMSIS/Device/ST/STM32L0xx/Include;               ../Drivers/CMSIS/Include;               ..\Drivers\MCU_EEPROM;               ..\Drivers\Wireless
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
target Lock (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L031K6Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: as above
  output: STM32L031K6Tx +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L031xx,DEVICE_TYPE_DOOR_LOCK
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
software components: CMSIS:CORE 4.3.0
